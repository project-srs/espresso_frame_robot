Commit message: update for v2 frame

File: espresso_frame_bringup/urdf/all.urdf (robot description, URDF)
Before this commit: robot test_robot, 5 links, 4 joints
Joints:
- joint front_laser_joint: origin xyz=0.141 0 0 rpy=0 0 0 -> xyz=0.140 0 0 rpy=0 0 3.141592
